Commit message: fix joint mismatch

File: urdf_tutorial/urdf/zeno_robot.urdf (robot description, URDF)
Before this commit: robot myrobot, 28 links, 27 joints
Joints:
- joint r_shoulder_pitch_joint: parent base_link -> chest_link
- joint torso_joint: parent pelvis_link -> base_link
